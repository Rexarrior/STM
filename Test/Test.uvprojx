# Keil uVision project Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./Inc/: stm32l1xx_it.h stm32l1xx_hal_conf.h main.h
    ./Src/: stm32l1xx_it.c stm32l1xx_hal_msp.c main.c
